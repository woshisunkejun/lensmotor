# IAR project AT32F423CCT7_WorkBench.ewp, settings and files
configuration AT32F423CCT7_WorkBench (ARM, debug)
  General.OGChipSelectEditMenu: AT32F423CCT7_v2 ArteryTek -AT32F423CCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F423CCT7; USE_STDPERIPH_DRIVER; AT_START_F423_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: AT32F423CCT7_WorkBench.srec
  ILINK.IlinkOutputFile: AT32F423CCT7_WorkBench.out
  ILINK.IlinkIcfFile: AT32F423xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ./: startup_at32f423.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f423.c
  group firmware
    ../../libraries/drivers/src/: at32f423_adc.c at32f423_crm.c at32f423_debug.c at32f423_dma.c at32f423_exint.c at32f423_flash.c at32f423_gpio.c at32f423_misc.c at32f423_pwc.c at32f423_tmr.c at32f423_usart.c
  group user
    ../src/: at32f423_int.c at32f423_wk_config.c debug_serial.c foc_controller.c foc_utils.c main.c multi_foc_controller.c simplefoc_c.c wk_adc.c wk_dma.c wk_gpio.c wk_system.c wk_tmr.c wk_usart.c
