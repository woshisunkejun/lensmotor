<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AT32F423CCT7_WorkBench.ewp</path>
    </project>
    <batchBuild />
</workspace>
